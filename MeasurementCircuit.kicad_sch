File: MeasurementCircuit.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U2 LTC2990

Commit message: updates
Other:
- moved on the sheet: U2
